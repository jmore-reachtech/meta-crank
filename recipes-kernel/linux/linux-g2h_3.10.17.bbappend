# Append path for reach layer to include kernel defconfig 
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
  
SRCREV = "856889c0add86b425f04f7c458ab14859b27b01a"
